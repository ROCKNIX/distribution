diff --git a/arch/arm64/boot/dts/rockchip/rk3566-miyoo-flip.dts b/arch/arm64/boot/dts/rockchip/rk3566-miyoo-flip.dts
new file mode 100644
index 000000000000..5081fe9f303e
--- /dev/null
+++ b/arch/arm64/boot/dts/rockchip/rk3566-miyoo-flip.dts
@@ -0,0 +1,61 @@
+// SPDX-License-Identifier: (GPL-2.0)
+/*
+ * Copyright (c) 2024 ROCKNIX (https://github.com/ROCKNIX)
+ */
+
+/dts-v1/;
+
+#include "rk3566-powkiddy-rgb30.dts"
+
+/ {
+        compatible = "miyoo,flip", "rockchip,rk3566";
+        model = "Miyoo Flip";
+
+	vcc5v0_host: regulator-vcc5v0-host {
+		compatible = "regulator-fixed";
+		enable-active-high;
+		gpio = <&gpio4 RK_PC5 GPIO_ACTIVE_HIGH>;
+		pinctrl-0 = <&vcc5v0_host_en>;
+		pinctrl-names = "default";
+		regulator-name = "vcc5v0_host";
+		vin-supply = <&dcdc_boost>;
+	};
+};
+
+&battery {
+	charge-full-design-microamp-hours = <3000000>;
+};
+
+&joypad {
+	sw3 {
+		gpios = <&gpio3 RK_PA5 GPIO_ACTIVE_LOW>;
+	};
+	sw4 {
+		gpios = <&gpio3 RK_PA6 GPIO_ACTIVE_LOW>;
+	};
+	sw5 {
+		gpios = <&gpio3 RK_PC2 GPIO_ACTIVE_LOW>;
+	};
+	sw6 {
+		gpios = <&gpio3 RK_PC3 GPIO_ACTIVE_LOW>;
+	};
+	sw11 {
+		gpios = <&gpio3 RK_PA1 GPIO_ACTIVE_LOW>;
+	};
+	sw16 {
+		gpios = <&gpio2 RK_PC1 GPIO_ACTIVE_HIGH>;
+	};
+	sw17 {
+		gpios = <&gpio2 RK_PC0 GPIO_ACTIVE_HIGH>;
+	};
+};
+
+&panel {
+	compatible = "rocknix,generic-dsi";
+	panel_description = "G size=68,121 delays=0,160,200,200,20 format=rgb888 lanes=2 flags=0xe03", "M clock=32000 horizontal=640,150,120,120 vertical=480,20,6,12 default=1", "M clock=32000 horizontal=640,150,130,120 vertical=480,20,104,12", "M clock=32010 horizontal=640,150,157,120 vertical=480,20,88,12", "M clock=32130 horizontal=640,150,152,120 vertical=480,20,93,12", "M clock=32890 horizontal=640,150,130,120 vertical=480,20,38,12", "M clock=38050 horizontal=640,150,150,120 vertical=480,20,89,12", "M clock=33600 horizontal=640,150,168,120 vertical=480,20,8,12", "M clock=32760 horizontal=640,150,140,120 vertical=480,20,8,12", "M clock=32750 horizontal=640,150,126,120 vertical=480,20,14,12", "M clock=43580 horizontal=640,150,138,120 vertical=480,20,39,12", "M clock=49140 horizontal=640,150,140,120 vertical=480,20,8,12", "M clock=64890 horizontal=640,150,120,120 vertical=480,20,13,12", "I seq=11 wait=250", "I seq=29 wait=32", "I seq=b9f11287", "I seq=b2780470", "I seq=b31010282803ff00000000", "I seq=b480", "I seq=b50a0a", "I seq=b82622f013", "I seq=ba318105f90e0e2000000000000000442500910a0000014f01000037", "I seq=bc47", "I seq=bf0211008004", "I seq=c0737350500000127300", "I seq=c17300323277f47777ccccffff1111000032", "I seq=c710000a0000000000edc500a5", "I seq=c810401e03", "I seq=cc0b", "I seq=e0000509293c3f3b37050a0c10131013121a000509293c3f3b37050a0c10131013121a", "I seq=e111119100000000", "I seq=e307070b0b0b0b00000000ff04c010", "I seq=e9c810020000b0b11131232880b0b127080004020000000004020000008888ba60240888888888888888ba713518888888888800000001000000000000000000", "I seq=ea970a820203070000000000008188ba17538888888888888088ba064288888888888823000002a500000000000000000000000000000000000000000000", "I seq=efffff01";
+};
+
+&vcc_wifi {
+	/delete-property/ enable-active-high;
+	gpio = <&gpio0 RK_PA0 GPIO_ACTIVE_LOW>;
+};
